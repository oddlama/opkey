# Repository oddlama/opkey

File README.md:

# OpKey

Optical Key Sensor and MIDI controller for acoustic pianos, because why not.

## Hardware

All hardware pcbs are designed in KiCad. You will find them in the `hardware/` folder.
Do not forget to include the provided library for all components which are not found in the standard library.

* The controller board
* The sensor board (the normal 15 sensors veriant and one remainder for the low part of the keyboard)
  - 15 sensor variant is stacked 5 times
  - 13+2 sensors variant terminates the chain at the left end of the keyboard and adds auxiliary inputs for two pedal sensors
* A mini board for auxiliary sensors (pedals)

### Connection Diagram

```
                     LED strip
 o─o─o─o─o─o─o─o─o─o─o─o─o─o─o─o─o─o─o─o─o─o─o─o─o─o─o────╖
                                                          ║
  ╔═══ Soft Pedal (Una Corda)                             ║
  ║ ╔═ Damp Pedal (Sustain)                               ║
  ║ ║                                                     ║
┌─╨─╨──────────┐ ┌────────────┐     ┌────────────┐  ┌─────╨──────┐
│ 13+2 Sensors │ │ 15 Sensors │  …  │ 15 Sensors │  │ Controller │
│    Board 1   ╞═╡   Board 2  ╞/ … /╡   Board 6  ╞══╡ Controller ╞═ [+5V]
└──────────────┘ └────────────┘     └────────────┘  └────────────┘
```

### Issues

* 5V rail needs to be regulated
* Has filling both sides with copper been a good idea?
* SPI signal quality is crappy (cannot get above 4-5MHz, while ADC could do 20MHz and ESP32 could do 80MHz)
* The flat cables weren't my best idea... They proved to be a real pain in the ass.
  (Very unusual part, expensive and not available in correct lengths)
* All sensors are currently in line with each other, while the pivot points for black keys
  differs from the pivot point of white keys. This causes black keys to have a lot more travel at the
  sensor than white keys.
* We definitely need a way to properly calibrate all keys. The reflected amount of light
  varies, because of the wood texture of the keys, voltage drop from the length of all modules,
  and probably some other factors (mounting angle difference, factory deviation for IR LEDs and sensors...)
* The low-pass filter seems to work fine, but maybe it should be tested properly.
* Could a differentiator be used after the sensor to get more accurate and comparable velocity measurements? 
* The reference volatage at the ADCs could have been a mistake,
  because the sensor output voltage is not regulated.
* Some deterministic BLE transmission every .5 seconds causes sensor values to fluctuate by 2-3 bits. (Some kind of BLE heartbeat?)
  This could be either an induced current in the sensing line, or more likely a voltage drop caused by the TX module.
  Though indeed my antenna is exactly in line with the long side of the module, and therefore most of the traces on that PCB.
* The 3 zener diode package for USB line protection is upside down. (Wrong part pinout or footprint selected)
* We need USB midi out for low latency, and pure MIDI out for even better latency (don't forget optocouplers).
* Replace ESP32 by several proper processors (would allow full ADC utilization, see Software#Issues below for more)

## Software

The software for the ESP32 controller currently works like this:

Core 0 is responsible for BLE communication and LED visualization.
The BLE framework is the nimble, which is the recommended BLE framework according to Espressif.
Unfortunately, it really isn't a piece of cake.
See my issues [#4012](https://github.com/espressif/esp-idf/issues/4012)
and [#4328](https://github.com/espressif/esp-idf/issues/4328),
lets hope that there won't be any other issues.

Core 1 has been completely dedicated to this single FreeRTOS thread, to reduce scheduling
to the bare minimum. This allows it to be fully utilized for SPI communication and key state
calculation. While in theory the whole scheduling could be disabled by actually removing the
core from FreeRTOS initialization (via `start1.c`), this would also prevent us from using
`stdout` for UART communication. So I can't focus on this while the software is still heavily debugged.
Nontheless, this still gives us somewhat deterministic timings between sensor reads (good enough - down to some us).

SPI communication is polling, allowing us to process the previous sample while the
hardware SPI driver is busy with transactions for the next sample.

### Software summary

#### Core 0:

* Reads sensor's over SPI 
* Calculates key states
* Notifies other modules if key is pressed

#### Core 1:

* System threads (BLE driver, ...)
* Handles BLE communication
* Controls LED strip (calculates color and send's LED states)

### Issues

* Can the two SPI channels be used simultaneously?
* BLE midi has unpredictable latency.
* Recorded files seem to be missing the time code correction (probably an arecordmidi problem)
* Even though the two cores should be operating simultaneously, they are heavily influenced
  by each other (forced cache synchronization, fences in FreeRTOS code). e.g. TX for BLE on core 0
  causes core 1 to slow down, which is like the best thing ever for deterministic timing requirements!
  Admit it, you simply gotta love it.
* Separated hardware for each "process" would most likely eliminate most of these concerns.
  - One processor for each ADC (for SPI communication and key state calculation).
  - One processor to convert these signals to MIDI line
  - One processor for visualization
  - External BLE processor (nRF51 with [bluetoe](https://github.com/TorstenRobitzki/bluetoe))

Please don't judge the code layout too much, the ESP SDK really seems to hate good code.
Their giant pile of bloated cmake prevents you from using proper cmake (and forces you to use flat code layout).

## Images

Some images of the finished PCBs and the assembly process, as well as the BLE fluctuation
can be found [here](IMAGES.md)

## KiCad design hardware/sensor_array_15_sensors/sensor_array_15_sensors.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C21, C23: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C16, C17, C18: 1µF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C19: 10µF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C20, C22: 10uF; CP_EIA-2012-15_AVX-P_Pad1.30x1.05mm_HandSolder
H1, H2, H3, H4, H5, H6: M2; MountingHole_2.2mm_M2_Pad_Via
J1, J2: Conn_01x17; Molex_200528-0170_1x17-1MP_P1.00mm_Horizontal
J3: Conn_01x04; PinHeader_1x04_P2.54mm_Horizontal
J4: Conn_01x04; Molex_200528-0040_1x04-1MP_P1.00mm_Horizontal
J5: Conn_01x03; PinHeader_1x03_P2.54mm_Horizontal
JP1, JP2, JP3, JP4, JP5, JP6: CS; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP7, JP8, JP9, JP10, JP11, JP12: SDO; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2, R3, R13, R14: 47; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4, R5, R6, R7, R8, R9, R10, R11, R12, R15, R16, R17, R18, R19, R20: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R21: 4k7; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1, RV2, RV3, RV4, RV5: 100; Potentiometer_Bourns_TC33X_Vertical
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15: QRE1113; OnSemi_CASE100CY
U16: ADS7953; TSSOP-38_4.4x9.7mm_P0.5mm
U17: LM4040DBZ-2.5; SOT-23

Connections:
+3V3: C16.2, C20.1, C21.2, J1.16, J2.2, U16.36
+5V: C17.1, C18.1, C22.1, C23.2, J1.1, J1.17, J2.1, J2.17, J5.3, R1.2, R2.2, R3.2, R13.2, R14.2, R21.2, U1.3, U2.3, U3.3, U4.3, U5.3, U6.3, U7.3, U8.3, U9.3, U10.3, U11.3, U12.3, U13.3, U14.3, U15.3, U16.5, U16.29
/CH0: C15.1, R20.2, U15.4, U16.28
/CH1: C14.1, R19.2, U14.4, U16.27
/CH2: C13.1, R18.2, U13.4, U16.26
/CH3: C12.1, R17.2, U12.4, U16.25
/CH4: C11.1, R16.2, U11.4, U16.24
/CH5: C10.1, R15.2, U10.4, U16.23
/CH6: C9.1, R12.2, U9.4, U16.22
/CH7: C8.1, R11.2, U8.4, U16.21
/CH8: C7.1, R10.2, U7.4, U16.18
/CH9: C6.1, R9.2, U6.4, U16.17
/CH10: C5.1, R8.2, U5.4, U16.16
/CH11: C4.1, R7.2, U4.4, U16.15
/CH12: C3.1, R6.2, U3.4, U16.14
/CH13: C2.1, R5.2, U2.4, U16.13
/CH14: C1.1, R4.2, U1.4, U16.12
/CH15: J5.2, U16.11
CS: JP1.2 (B), JP2.2 (B), JP3.2 (B), JP4.2 (B), JP5.2 (B), JP6.2 (B), U16.31
CS0: J1.15, J2.3, JP1.1 (A)
CS1: J1.14, J2.4, JP2.1 (A)
CS2: J1.13, J2.5, JP3.1 (A)
CS3: J1.12, J2.6, JP4.1 (A)
CS4: J1.11, J2.7, JP5.1 (A)
CS5: J1.10, J2.8, JP6.1 (A)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, C17.2, C18.2, C19.2, C20.2, C21.1, C22.2, C23.1, H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, J1.5, J1.9, J2.9, J2.13, J5.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, U3.2 (K), U6.2 (K), U9.2 (K), U12.2 (K), U15.2 (K), U16.3, U16.6, U16.9, U16.10, U16.19, U16.20, U16.30, U16.35, U17.2 (A)
GPIO0: J3.4, J4.1, U16.37
GPIO1: J3.3, J4.2, U16.38
GPIO2: J3.2, J4.3, U16.1
GPIO3: J3.1, J4.4, U16.2
unnamed: C19.1, R21.1, U16.4, U17.1 (K)
unnamed: R1.1, RV1.1, RV1.2
unnamed: R2.1, RV2.1, RV2.2
unnamed: R3.1, RV3.1, RV3.2
unnamed: R13.1, RV4.1, RV4.2
unnamed: R14.1, RV5.1, RV5.2
unnamed: RV1.3, U1.1 (A)
unnamed: RV2.3, U4.1 (A)
unnamed: RV3.3, U7.1 (A)
unnamed: RV4.3, U10.1 (A)
unnamed: RV5.3, U13.1 (A)
unnamed: U1.2 (K), U2.1 (A)
unnamed: U2.2 (K), U3.1 (A)
unnamed: U4.2 (K), U5.1 (A)
unnamed: U5.2 (K), U6.1 (A)
unnamed: U7.2 (K), U8.1 (A)
unnamed: U8.2 (K), U9.1 (A)
unnamed: U10.2 (K), U11.1 (A)
unnamed: U11.2 (K), U12.1 (A)
unnamed: U13.2 (K), U14.1 (A)
unnamed: U14.2 (K), U15.1 (A)
unnamed: U16.7, U16.8
SCLK: JP11.2 (B), JP12.2 (B), U16.32
SCLK0: J1.6, J2.12, JP11.1 (A)
SCLK1: J1.2, J2.16, JP12.1 (A)
SDI: JP9.2 (B), JP10.2 (B), U16.33
SDI0: J1.7, J2.11, JP9.1 (A)
SDI1: J1.3, J2.15, JP10.1 (A)
SDO: JP7.2 (B), JP8.2 (B), U16.34
SDO0: J1.8, J2.10, JP7.1 (A)
SDO1: J1.4, J2.14, JP8.1 (A)

Notes on the sheet:
Sensor Array 1-9
Sensor Array 10-15
Power Flags
Mounting Holes
ADC
REFP resistance is 100k, so Iq is 25 µA. Rs = (Vs - Vr) / (Ir + Iq), settle for Ir + Iq = 500µA => R_S = 2.5V/500µA = 5k Round to E12 = 4k7
GPIO Header
SPI & Power Connectors
CS Line Select
Power Buffer
CH15 Header
SPI Line Select

Board: 2 copper layers, 205.0 x 30.0 mm, 89 parts (0 on the bottom side), 61 nets.

## KiCad design hardware/sensor_auxiliary/sensor_auxiliary.kicad_pcb

Schematic: sensor_auxiliary.sch, Sensor Auxiliary

Parts:
C1, C3: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2: 10uF; CP_EIA-2012-15_AVX-P_Pad1.30x1.05mm_HandSolder
H1, H2, H3, H4: M2; MountingHole_2.2mm_M2_Pad_Via
J1: Conn_01x04; Molex_200528-0040_1x04-1MP_P1.00mm_Horizontal
R1: 150; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1: 200; Potentiometer_Bourns_TC33X_Vertical
U1: QRE1113; OnSemi_CASE100CY

Connections:
+5V: C2.1, C3.2, J1.3, R1.1, U1.3
/SENSOR_AUX: C1.1, J1.1, R2.2, U1.4
GND: C1.2, C2.2, C3.1, H1.1, H2.1, H3.1, H4.1, J1.2, J1.4, R2.1, U1.2 (K)
unnamed: R1.2, RV1.2, RV1.3
unnamed: RV1.1, U1.1 (A)

Notes on the sheet:
Sensor
Power Flags
Power Buffer
Mounting Holes
Connector

Board: 2 copper layers, 25.0 x 25.0 mm, 12 parts (0 on the bottom side), 5 nets.

## KiCad design hardware/main_controller/main_controller.kicad_pcb

Board: 2 copper layers, 70.0 x 40.0 mm, 37 parts (0 on the bottom side), 34 nets.

Parts:
C1, C4, C6, C8: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C3: 47µF; CP_EIA-2012-15_AVX-P_Pad1.30x1.05mm_HandSolder
C5, C7: 10uF; CP_EIA-2012-15_AVX-P_Pad1.30x1.05mm_HandSolder
D1: SP0503BAHT; SOT-143
D2: LED_Blue_2V6_2mA; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: M2; MountingHole_2.2mm_M2_Pad_Via
J1, J2: Conn_01x17; Molex_200528-0170_1x17-1MP_P1.00mm_Horizontal
J3: Barrel_Jack; BarrelJack_CUI_PJ-063AH_Horizontal
J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J5, J6: Conn_01x04; Molex_200528-0040_1x04-1MP_P1.00mm_Horizontal
J7: USB_B_Micro; USB_Micro-B_Molex_47346-0001
J8, J9: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
JP1, JP2: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
Q1, Q2: 2N7002; SOT-23
R1: 24k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 47k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3: 4k7; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1, SW2: SW_Push; SW_SPST_PTS645
U1: ESP32-WROOM-32U
U2: CP2104; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
U3: LM1117-3.3; SOT-223

Connections:
+3V3: C1.1, C3.1, C5.1, C6.2, D2.2, J1.16, J2.2, JP1.3, JP2.3, R3.2, R4.2, U1.2, U2.5, U2.6, U2.7, U3.2
+5V: C2.1, C7.1, C8.2, J1.1, J1.17, J2.1, J2.17, J4.2, J8.1, J9.1, JP1.1, JP2.1, U3.3
CS0: J1.15, J2.3, U1.23
CS1: J1.14, J2.4, U1.27
CS2: J1.13, J2.5, U1.28
CS3: J1.12, J2.6, U1.29
CS4: J1.11, J2.7, U1.10
CS5: J1.10, J2.8, U1.11
DTR: C4.2, Q1.1, Q2.2, U2.23
EN: C4.1, Q1.3, R4.1, SW1.2, U1.3
GND: C1.2, C2.2, C3.2, C5.2, C6.1, C7.2, C8.1, D1.1, H1.1, H2.1, H3.1, H4.1, J1.5, J1.9, J2.9, J2.13, J3.2, J5.4, J6.4, J7.5, J7.6, J8.3, J9.3, R2.1, SW1.1, SW2.1, U1.1, U1.15, U1.38, U2.2, U2.25, U3.1
GPIO0: Q2.3, R5.1, SW2.2, U1.25
HSPI_MISO: J1.8, J2.10, U1.14
HSPI_MOSI: J1.7, J2.11, U1.16
HSPI_SCLK: J1.6, J2.12, U1.13
I2C_SCL: J5.2, J6.2, U1.36
I2C_SDA: J5.3, J6.3, U1.33
IO32: J8.2, U1.8
IO33: J9.2, U1.9
unnamed: D2.1, R5.2
unnamed: J3.1, J4.1
unnamed: J5.1, JP1.2
unnamed: J6.1, JP2.2
unnamed: R1.2, R2.2, U2.8
unnamed: R3.1, U2.9
RTS: Q1.2, Q2.1, U2.19
RXD0: U1.34, U2.21
SCLK1: J1.2, J2.16, U1.30
SDI1: J1.3, J2.15, U1.37
SDO1: J1.4, J2.14, U1.31
TXD0: U1.35, U2.20
USB_D+: D1.4, J7.3, U2.3
USB_D-: D1.3, J7.2, U2.4
USB_VBUS: D1.2, J7.1, R1.1

## KiCad design hardware/sensor_array_Csharp_octave/sensor_array_Csharp_octave.kicad_pcb

Board: 2 copper layers, 161.0 x 25.0 mm, 54 parts (0 on the bottom side), 30 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C15, C16: 10uF; CP_EIA-2012-15_AVX-P_Pad1.30x1.05mm_HandSolder
J1, J2: Conn_01x02; PinHeader_1x02_P2.54mm_Horizontal
J3, J4, J5, J6: Conn_01x04; PinHeader_1x04_P2.54mm_Horizontal
R1, R2, R3, R4: 47; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1, RV2, RV3, RV4: 100; Potentiometer_Bourns_TC33X_Vertical
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12: QRE1113; OnSemi_CASE100CY

Connections:
+5V: C13.2, C14.2, C15.1, C16.1, J1.2, J2.2, R1.2, R2.2, R3.2, R4.2, U1.3, U2.3, U3.3, U4.3, U5.3, U6.3, U7.3, U8.3, U9.3, U10.3, U11.3, U12.3
/SENSOR_A: C9.1, J5.4, R13.2, U9.4
/SENSOR_B: C11.1, J6.3, R15.2, U11.4
/SENSOR_Bb: C10.1, J6.2, R14.2, U10.4
/SENSOR_C: C12.1, J6.4, R16.2, U12.4
/SENSOR_C#: C1.1, J3.2, R5.2, U1.4
/SENSOR_D: C2.1, J3.3, R6.2, U2.4
/SENSOR_E: C4.1, J4.2, R8.2, U4.4
/SENSOR_Eb: C3.1, J3.4, R7.2, U3.4
/SENSOR_F: C5.1, J4.3, R9.2, U5.4
/SENSOR_F#: C6.1, J4.4, R10.2, U6.4
/SENSOR_G: C7.1, J5.2, R11.2, U7.4
/SENSOR_G#: C8.1, J5.3, R12.2, U8.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.2, C16.2, J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, U3.2, U6.2, U9.2, U12.2
unnamed: R1.1, RV1.2, RV1.3
unnamed: R2.1, RV2.2, RV2.3
unnamed: R3.1, RV3.2, RV3.3
unnamed: R4.1, RV4.2, RV4.3
unnamed: RV1.1, U1.1
unnamed: RV2.1, U4.1
unnamed: RV3.1, U7.1
unnamed: RV4.1, U10.1
unnamed: U1.2, U2.1
unnamed: U2.2, U3.1
unnamed: U4.2, U5.1
unnamed: U5.2, U6.1
unnamed: U7.2, U8.1
unnamed: U8.2, U9.1
unnamed: U10.2, U11.1
unnamed: U11.2, U12.1

## KiCad design hardware/sensor_array_A_C/sensor_array_A_C.kicad_pcb

Board: 2 copper layers, 50.0 x 25.0 mm, 24 parts (0 on the bottom side), 12 nets.

Parts:
C1, C2, C3, C4, C5, C6: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C7, C8: 10uF; CP_EIA-2012-15_AVX-P_Pad1.30x1.05mm_HandSolder
J1, J2, J3: Conn_01x02; PinHeader_1x02_P2.54mm_Horizontal
J4: Conn_01x04; PinHeader_1x04_P2.54mm_Horizontal
R1, R2: 91; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R4, R5, R6: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1, RV2: 100; Potentiometer_Bourns_TC33X_Vertical
U1, U2, U3, U4: QRE1113; OnSemi_CASE100CY

Connections:
+5V: C5.2, C6.2, C7.1, C8.1, J1.2, J2.2, R1.1, R2.1, U1.3, U2.3, U3.3, U4.3
/SENSOR_A: C1.1, J3.2, R3.2, U1.4
/SENSOR_B: C3.1, J4.3, R5.2, U3.4
/SENSOR_Bb: C2.1, J4.2, R4.2, U2.4
/SENSOR_C: C4.1, J4.4, R6.2, U4.4
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.2, C8.2, J1.1, J2.1, J3.1, J4.1, R3.1, R4.1, R5.1, R6.1, U2.2, U4.2
unnamed: R1.2, RV1.2, RV1.3
unnamed: R2.2, RV2.2, RV2.3
unnamed: RV1.1, U1.1
unnamed: RV2.1, U3.1
unnamed: U1.2, U2.1
unnamed: U3.2, U4.1

## Commit log

2019-06-25 Added gitignore
2019-06-25 Added cpp_utils component from esp32-snippets
2019-06-25 Added CMakeLists.txt
2019-06-25 Added current testing version
2019-06-25 Fixed comments
2019-06-25 Drastically improved sample rate by using DMA ready memory and batching transfers
2019-07-01 WIP: testing
2019-07-18 Added sensor schematics and pcbs
2019-07-18 Renamed sensor_standalone to sensor_auxiliary
2019-07-21 Removed old sensor arrays, added new integrated 15 channel sensor array
2019-07-23 Relayout for 2 SPI master lines, finished 14 and 15 sensor boards, finished auxiliary board
2019-07-29 Created main controller. Prototypes finished.
2019-07-29 Fixed OpKey logo (JLC dislikes negative angles), added gbr files
2019-07-30 Final changes, regenerated gerber files
2019-08-08 set name to opkey everywhere, implemented SpiHost and SpiDevice
2019-08-08 Added SpiDevice::Transfer()
2019-08-09 Test works
2019-08-10 Full cleanup, begin proper implementation
2019-08-16 WIP: Restructuring and splitting into classes
2019-08-16 renamed file
2019-08-16 Prepare basic component classes
2019-08-17 Implemented profiler
2019-08-17 Removed cpp_utils
2019-08-18 Implemented Rmt LedStrip controller
2019-08-18 renamed sk6812.h, prepare pixel class
2019-08-18 RmtLedStrip controller working.
2019-08-18 Implemented interrupt profiling
2019-08-18 Added interface for exception visualization
2019-08-18 Added entt for signal handling
2019-08-18 entt to master
2019-08-18 Small warning fix
2019-08-19 Implemented more events, begin optimizing ADC readout
2019-08-19 Adc sampling code finished, created temporary core-0 task for visualization
2019-08-19 Implemented sensor history and basic key state calculation.
2019-08-19 Implemented async visualizer
2019-08-19 remove cpp_utils from readme
2019-08-20 Basic visualzing ready
2019-08-20 Dirty ble example
2019-08-21 Rename BleServer -> BleInterface
2019-08-26 Remove most dynamic allocation, add BLE ideas
2019-08-28 fixed namespace names, begin with ble templating
2019-08-28 WIP: Ble templating
2019-08-28 WIP: Ble template outline finished
2019-09-01 WIP: Templated Ble interface mostly compiling
2019-09-01 WIP: Fixed some minor problems
2019-09-01 Successful ble compilation, but missing callback implementation
2019-09-01 Callbacks confirmed working
2019-09-02 Added FixedValue and BindVariable implementations
2019-09-02 Added connect/disconnect handler, work towards OnSubscribe support
2019-09-02 Added ability to recursively find classes by a given mixin at compiletime. For example to find a characteristic by uuid when knowing only the full server type.
2019-09-02 Implemented OnSubscribe.
2019-09-02 Assert write access for WriteNoResponse
2019-09-03 Implement AdvertiseUuid tag for server to advertise a single custom uuid
2019-09-03 Note to self: Using the correct MIDI UUID helps.
2019-09-03 Added IndicateAll() and NotifyAll()
2019-09-03 Implemented ble array for usage with variable packet sizes.
2019-09-03 Working, but severe delay when calling Notify() a lot.
2019-09-03 notify delay debugging
2019-09-04 Resolved notify hangup: Reported a bug to esp-idf (in esp nimble port): https://github.com/espressif/esp-idf/issues/4012
2019-09-06 Implemented minimal packet based server (for mode setting etc.)
2019-09-06 Implemented global mode system, a calibration algorithm and visualization
2019-09-06 Implemented calibration data saving and restoring
2019-09-06 Minor cleanup
2019-09-07 Added single sensor tracing mode and host application to convert the data to a plottable format
2019-09-07 Added quick plotter
2019-09-07 Graphs smoothed and aligned on attack point
2019-09-08 Automated plotting and waveform capture
2019-09-09 Better data transmission now that screen can't f it up
2019-09-09 Revert transmittion method for reliability
2019-09-10 bandpass audio
2019-09-10 Removed sensor history in favor of time and memory efficient logic states
2019-09-10 Added HSV converter, visualized new velocity
2019-09-20 Fixed recording keys with sharp symbol
2019-09-21 Added damper and soft pedal midi support and visualization
2019-10-06 Considerations for new detection algorithm
2019-10-06 Increased ADC speed by processing data while polling for results, new key detection algorithm (WIP)
2019-10-07 Fine tuning of new alorithm
2019-10-07 New detection method O.K. for now
2019-10-07 Removed debug visualization
2019-10-07 Improved visualizer with better pedal support and general decay
2019-10-09 Switchted single sensor mode to a continous plot with better audio correlation
2019-10-09 Added trigger detection also in plot
2019-10-10 Moved contributed python and scripts to own directory.
2019-10-10 Ignore __pycache__
2019-10-11 WIP: peak finding
2019-10-12 Extraction v0.1 ready.
2019-10-12 Added first version of ai to fit data.
2019-10-12 raw pos training
2019-10-13 New dataset trained a good model
2019-10-13 Implemented keras model -> c++; added first model
2019-10-13 Fixed bias extraction bug caused by typo
2019-10-13 Removed debug prints
2019-10-24 Added timestamped midi messages; Added midi message recv sink; New small velocity detection model;
2019-10-27 Warm colors now; Also led input is now possible on ch0
2019-11-12 Trying to figure out better position algorithm
2019-11-12 New algo in place
2019-12-24 Adjusted trigger settings
2019-12-24 MIT license.
2019-12-24 Added images to readme
2019-12-24 Fixed image url, images to separate md file
2019-12-24 Image order
2020-01-08 Update license year
2020-09-01 WIP: Disable adc 6 (connectivity issues), adjust color ramp
